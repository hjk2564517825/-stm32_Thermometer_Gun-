# Keil uVision project peoject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: peoject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CMSIS;..\StdPeriph_Driver\inc;..\USER;..\MCode\LED;..\MCode\KEY;..\MCode\BEEP;..\MCode\DELAY;..\MCode\TIM;..\MCode\USART;..\MCode\HCSR04;..\MCode\OLED;..\MCode\DHT11;..\MCode\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group StdPeripth_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_i2c.c
  group USER
    ../USER/: main.c
  group MCode
    ../MCode/LED/: led.c
    ../MCode/KEY/: key.c
    ../MCode/BEEP/: beep.c
    ../MCode/DELAY/: delay.c
    ../MCode/TIM/: tim.c
    ../MCode/USART/: usart.c
    ../MCode/HCSR04/: hcsr04.c
    ../MCode/OLED/: oled.c
    ../MCode/DHT11/: DHT11.c
    ../MCode/IIC/: IIC.c
